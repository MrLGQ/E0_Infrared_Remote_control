<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>cmsis</name>
    <file>
      <name>$PROJ_DIR$\..\cmsis\core_cm3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\core_cmFunc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\core_cmInstr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\stm32_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\stm32_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\stm32f10x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\stm32f10x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\system_stm32f10x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cmsis\system_stm32f10x.h</name>
    </file>
  </group>
  <group>
    <name>driverlib</name>
    <file>
      <name>$PROJ_DIR$\..\driverlib\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\stm32f10x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>source</name>
    <file>
      <name>$PROJ_DIR$\..\source\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\enocean.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\ir.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\STM32_Flash_WR.c</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_cl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_hd.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_hd_vl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_ld.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_ld_vl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_md.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_md_vl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\startup\startup_stm32f10x_xl.s</name>
    </file>
  </group>
</project>


